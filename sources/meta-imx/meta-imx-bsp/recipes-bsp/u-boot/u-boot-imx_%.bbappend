FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:imx8mp-debix-model-ab = " file://0001-debix-model-ab-fdtfile.cfg"
