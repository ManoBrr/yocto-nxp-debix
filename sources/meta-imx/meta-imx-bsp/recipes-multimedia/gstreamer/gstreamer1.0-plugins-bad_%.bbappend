PACKAGECONFIG:remove = "rsvg"